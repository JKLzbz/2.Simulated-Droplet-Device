# Keil uVision project OV5640.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV5640 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\DCMI;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\OV5640;..\HARDWARE\TIMER;..\SYSTEM\delay;..\SYSTEM\sys;..\USMART;..\HARDWARE\BEEP;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\SRAM;..\HARDWARE\W25QXX;..\FATFS\src;..\FATFS\exfuns;..\MALLOC;..\PICTURE;..\TEXT;..\FDC2214;..\VL53L1X\core;..\VL53L1X\demo;..\VL53L1X\platform;..\USER;..\HARDWARE\UART1;..\HARDWARE\UART2;..\SYSTEM\usart;..\M8266WIFI;..\Temp;..\HARDWARE\EXTI;..\MPU6050;..\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/BEEP/: beep.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV5640/: ov5640.c sccb.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_exti.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group MALLOC
    ../MALLOC/: malloc.c
  group REDME
    ../: readme.txt
  group FDC2214
    ../FDC2214/: fdc2214.c
  group M8266WIFI
    ../M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFI_ops.c test_m8266wifi.c WiFiSend.c M8266WIFIDrv_STM32F4xx.a WiFiReceive.c
  group VL53L1X
    ../VL53L1X/core/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../VL53L1X/demo/: vl53l1x.c
    ../VL53L1X/platform/: vl53l1_platform.c vl53l1x_i2c.c
  group Temp
    ../Temp/: STM32_GD60914.c
  group MPU6050
    ../MPU6050/: mpu6050.c myiic.c
    ../MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
